# Keil uVision project Wireless_Sensor.uvprojx, settings and files
target nrf52840_xxaa (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: nRF52840_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.35.0
  cpu: IROM(0x00000000,0x100000) IRAM(0x20000000,0x40000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52840_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: DEV_KIT DEBUG DEBUG_LOG DEBUG_TASKS APP_TIMER_V2 APP_TIMER_V2_RTC1_ENABLED CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD FREERTOS NRF_SD_BLE_API_VERSION=7 S140 SOFTDEVICE_PRESENT  NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  c misc: --reduce_paths
  c include: ..\..\..\config;..\..\..\..\sdk\components;..\..\..\..\sdk\components\boards;..\..\..\..\sdk\components\libraries\atomic;..\..\..\..\sdk\components\libraries\balloc;..\..\..\..\sdk\components\libraries\bsp;..\..\..\..\sdk\components\libraries\delay;..\..\..\..\sdk\components\libraries\experimental_section_vars;..\..\..\..\sdk\components\libraries\log;..\..\..\..\sdk\components\libraries\log\src;..\..\..\..\sdk\components\libraries\memobj;..\..\..\..\sdk\components\libraries\ringbuf;..\..\..\..\sdk\components\libraries\strerror;..\..\..\..\sdk\components\libraries\util;..\..\..;..\..\..\..\sdk\external\fprintf;..\..\..\..\sdk\external\segger_rtt;..\..\..\..\sdk\integration\nrfx;..\..\..\..\sdk\integration\nrfx\legacy;..\..\..\..\sdk\modules\nrfx;..\..\..\..\sdk\modules\nrfx\drivers\include;..\..\..\..\sdk\modules\nrfx\hal;..\config;..\..\..\..\sdk\components\libraries\atomic_fifo;..\..\..\..\sdk\components\libraries\experimental_section_vars;..\..\..\..\sdk\components\libraries\fifo;..\..\..\..\sdk\components\libraries\hardfault;..\..\..\..\sdk\components\libraries\hardfault\nrf52;..\..\..\..\sdk\components\libraries\mutex;..\..\..\..\sdk\components\libraries\pwr_mgmt;..\..\..\..\sdk\components\libraries\queue;..\..\..\..\sdk\components\libraries\scheduler;..\..\..\..\sdk\components\libraries\sortlist;..\..\..\..\sdk\components\libraries\timer;..\..\..\..\sdk\components\libraries\usbd;..\..\..\..\sdk\components\libraries\usbd\class\cdc;..\..\..\..\sdk\components\libraries\usbd\class\cdc\acm;..\..\..\..\sdk\components\libraries\util;..\..\..\..\sdk\external\fnmatch;..\..\..\..\sdk\external\utf_converter;..\..\..\..\sdk\components\libraries\fds;..\..\..\..\sdk\components\libraries\fstorage;..\..\..\..\sdk\components\libraries\crc16;..\..\..\..\sdk\components\libraries\mem_manager;..\..\..\..\sdk\components\libraries\bsp;..\..\..\..\sdk\components\libraries\button;..\..\..\My_Libraries;..\..\..\..\sdk\external\freertos\config;..\..\..\..\sdk\external\freertos\portable\ARM\nrf52;..\..\..\..\sdk\external\freertos\portable\CMSIS\nrf52;..\..\..\..\sdk\external\freertos\source\include;..\..\..\..\sdk\components\ble\ble_advertising;..\..\..\..\sdk\components\ble\ble_dtm;..\..\..\..\sdk\components\ble\ble_link_ctx_manager;..\..\..\..\sdk\components\ble\ble_racp;..\..\..\..\sdk\components\ble\ble_services\ble_ancs_c;..\..\..\..\sdk\components\ble\ble_services\ble_ans_c;..\..\..\..\sdk\components\ble\ble_services\ble_bas;..\..\..\..\sdk\components\ble\ble_services\ble_bas_c;..\..\..\..\sdk\components\ble\ble_services\ble_cscs;..\..\..\..\sdk\components\ble\ble_services\ble_cts_c;..\..\..\..\sdk\components\ble\ble_services\ble_dfu;..\..\..\..\sdk\components\ble\ble_services\ble_dis;..\..\..\..\sdk\components\ble\ble_services\ble_gls;..\..\..\..\sdk\components\ble\ble_services\ble_hids;..\..\..\..\sdk\components\ble\ble_services\ble_hrs;..\..\..\..\sdk\components\ble\ble_services\ble_hrs_c;..\..\..\..\sdk\components\ble\ble_services\ble_hts;..\..\..\..\sdk\components\ble\ble_services\ble_ias;..\..\..\..\sdk\components\ble\ble_services\ble_ias_c;..\..\..\..\sdk\components\ble\ble_services\ble_lbs;..\..\..\..\sdk\components\ble\ble_services\ble_lbs_c;..\..\..\..\sdk\components\ble\ble_services\ble_lls;..\..\..\..\sdk\components\ble\ble_services\ble_nus;..\..\..\..\sdk\components\ble\ble_services\ble_nus_c;..\..\..\..\sdk\components\ble\ble_services\ble_rscs;..\..\..\..\sdk\components\ble\ble_services\ble_rscs_c;..\..\..\..\sdk\components\ble\ble_services\ble_tps;..\..\..\..\sdk\components\ble\common;..\..\..\..\sdk\components\ble\nrf_ble_gatt;..\..\..\..\sdk\components\ble\nrf_ble_qwr;..\..\..\..\sdk\components\ble\peer_manager;..\..\..\..\sdk\components\softdevice\common;..\..\..\..\sdk\components\softdevice\s140\headers;..\..\..\..\sdk\components\softdevice\s140\headers\nrf52;..\..\..\..\sdk\components\libraries\atomic_flags
  asm define: BOARD_PCA10056 BSP_DEFINES_ONLY CONFIG_GPIO_AS_PINRESET FLOAT_ABI_HARD NRF52840_XXAA __HEAP_SIZE=8192 __STACK_SIZE=8192
  asm misc: --cpreproc_opts=-DBOARD_PCA10056,-DBSP_DEFINES_ONLY,-DCONFIG_GPIO_AS_PINRESET,-DFLOAT_ABI_HARD,-DNRF52840_XXAA,-D__HEAP_SIZE=8192,-D__STACK_SIZE=8192
  asm include: ..\..\..\config;..\..\..\..\..\..\components;..\..\..\..\..\..\components\boards;..\..\..\..\..\..\components\drivers_nrf\nrf_soc_nosd;..\..\..\..\..\..\components\libraries\atomic;..\..\..\..\..\..\components\libraries\balloc;..\..\..\..\..\..\components\libraries\bsp;..\..\..\..\..\..\components\libraries\delay;..\..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\..\components\libraries\log;..\..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\..\components\libraries\memobj;..\..\..\..\..\..\components\libraries\ringbuf;..\..\..\..\..\..\components\libraries\strerror;..\..\..\..\..\..\components\libraries\util;..\..\..;..\..\..\..\..\..\external\fprintf;..\..\..\..\..\..\external\segger_rtt;..\..\..\..\..\..\integration\nrfx;..\..\..\..\..\..\integration\nrfx\legacy;..\..\..\..\..\..\modules\nrfx;..\..\..\..\..\..\modules\nrfx\drivers\include;..\..\..\..\..\..\modules\nrfx\hal;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x27000 size 0xd9000
  memory RVCT9: RAM 0x20002ae8 size 0x3d518
  link misc: --diag_suppress 6330
  group Application
    ../../../: main.c
    ../config/: sdk_config.h
  group nRF_Drivers
    ../../../../sdk/integration/nrfx/legacy/: nrf_drv_clock.c nrf_drv_power.c nrf_drv_twi.c
    ../../../../sdk/modules/nrfx/soc/: nrfx_atomic.c
    ../../../../sdk/modules/nrfx/drivers/src/prs/: nrfx_prs.c
    ../../../../sdk/modules/nrfx/drivers/src/: nrfx_twi.c nrfx_twim.c nrfx_clock.c nrfx_gpiote.c nrfx_power.c nrfx_usbd.c nrfx_systick.c nrfx_nvmc.c nrfx_saadc.c
  group nRF_Libraries
    ../../../../sdk/components/libraries/util/: app_error.c app_error_handler_keil.c app_error_weak.c app_util_platform.c nrf_assert.c
    ../../../../sdk/components/libraries/atomic/: nrf_atomic.c
    ../../../../sdk/components/libraries/balloc/: nrf_balloc.c
    ../../../../sdk/external/fprintf/: nrf_fprintf.c nrf_fprintf_format.c
    ../../../../sdk/components/libraries/memobj/: nrf_memobj.c
    ../../../../sdk/components/libraries/ringbuf/: nrf_ringbuf.c
    ../../../../sdk/components/libraries/strerror/: nrf_strerror.c
    ../../../../sdk/components/libraries/fifo/: app_fifo.c
    ../../../../sdk/components/libraries/scheduler/: app_scheduler.c
    ../../../../sdk/components/libraries/usbd/: app_usbd.c app_usbd_core.c app_usbd_serial_num.c app_usbd_string_desc.c
    ../../../../sdk/external/fnmatch/: fnmatch.c
    ../../../../sdk/components/libraries/hardfault/: hardfault_implementation.c
    ../../../../sdk/components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ../../../../sdk/components/libraries/atomic_fifo/: nrf_atfifo.c
    ../../../../sdk/components/libraries/pwr_mgmt/: nrf_pwr_mgmt.c
    ../../../../sdk/components/libraries/queue/: nrf_queue.c
    ../../../../sdk/components/libraries/experimental_section_vars/: nrf_section_iter.c
    ../../../../sdk/components/libraries/sortlist/: nrf_sortlist.c
    ../../../../sdk/components/libraries/crc16/: crc16.c
    ../../../../sdk/components/libraries/fds/: fds.c
    ../../../../sdk/components/libraries/fstorage/: nrf_fstorage.c nrf_fstorage_sd.c
    ../../../../sdk/components/libraries/mem_manager/: mem_manager.c
    ../../../../sdk/components/libraries/timer/: app_timer_freertos.c
    ../../../../sdk/components/libraries/atomic_flags/: nrf_atflags.c
    ../../../../sdk/components/libraries/usbd/class/cdc/acm/: app_usbd_cdc_acm.c
  group nRF_Log
    ../../../../sdk/components/libraries/log/src/: nrf_log_backend_rtt.c nrf_log_backend_serial.c nrf_log_default_backends.c nrf_log_frontend.c nrf_log_str_formatter.c
  group nRF_Segger_RTT
    ../../../../sdk/external/segger_rtt/: SEGGER_RTT.c SEGGER_RTT_printf.c SEGGER_RTT_Syscalls_KEIL.c
  group My_Libraries
    ../../../My_Libraries/: AD5933.c flashManager.c gpioteManager.c sensorFunctions.c sensorTasks.c testFunctions.c twiManager.c usbManager.c bleManager.c adcManager.c
  group FreeRTOS
    ../../../../sdk/external/freertos/source/: list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../sdk/external/freertos/source/portable/MemMang/: heap_1.c
    ../../../../sdk/external/freertos/portable/ARM/nrf52/: port.c
    ../../../../sdk/external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group UTF8/16 converter
    ../../../../sdk/external/utf_converter/: utf.c
  group nRF_BLE
    ../../../../sdk/components/ble/common/: ble_advdata.c ble_conn_params.c ble_conn_state.c ble_srv_common.c
    ../../../../sdk/components/ble/ble_advertising/: ble_advertising.c
    ../../../../sdk/components/ble/ble_link_ctx_manager/: ble_link_ctx_manager.c
    ../../../../sdk/components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
    ../../../../sdk/components/ble/nrf_ble_qwr/: nrf_ble_qwr.c
    ../../../../sdk/components/ble/ble_services/ble_nus/: ble_nus.c
  group nRF_SoftDevice
    ../../../../sdk/components/softdevice/common/: nrf_sdh.c nrf_sdh_ble.c nrf_sdh_soc.c nrf_sdh_freertos.c
software components: CMSIS:CORE 5.3.0, Device:Startup 8.35.0
